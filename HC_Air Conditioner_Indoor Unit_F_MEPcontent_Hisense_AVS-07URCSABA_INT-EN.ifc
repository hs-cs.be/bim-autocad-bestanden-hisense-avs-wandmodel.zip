Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-02-06T09:29:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 06 09:29:59 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{D734D604-7774-4B48-A942-3F43BE8A2724}\ifc * Database version: 5507 * Database creation date: Tue Feb 06 09:29:58 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Feb 06 09:29:58 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 06 09:29:58 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcUnitaryEquipment: AVS-07URCSABA, HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVS-07-24_INT-EN:AVS-07URCSABA:1321918
In: V00
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 075-079-084, Color RGB 245-245-245
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 230 mm; Drain Diameter: 32 mm; Height: 315 mm; Refrigerant Gas Diameter: 12.7 mm; Refrigerant Liquid Diameter: 6.35 mm; Width: 960 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Wall mounted indoor unit; Article Type: AVS-07URCSABA; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Wall mounted indoor unit; EMCS Version: 3.0; ETIM Article Class: EC000403; Family Version: 11.12; Manufacturer: Hisense; Manufacturer Art. No.: AVS-07URCSABA; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVS-07URCSABA; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: Wall mounted type; Revit Version: 2016; Type Name: AVS-07URCSABA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Grey: Color RGB 075-079-084; White: Color RGB 245-245-245
Type - Mechanical - Loads - Airflow Rate (m3/min): 660; Cooling Capacity (kW): 2.2; Heating Capacity (kW): 2.5; Sound Pressure Level (dB(A)): 28; Unit Weight (kg): 13.5
Type - Other - Category: Mechanical Equipment; Family Name: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVS-07-24_INT-EN; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Elevation: 0 mm
Dimensions - Area: 2.86829 m2; Plate Angle: 45 deg; Volume: 0.457009 m3
Electrical - Loads - Power: 50 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Power,Undefined,Sanitary
Other - Back Clearance Safe: 150 mm; Family: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVS-07-24_INT-EN: AVS-07URCSABA; Family and Type: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVS-07-24_INT-EN: AVS-07URCSABA; Front Clearance Safe: 1000 mm; Gas Connector Angle: 180 deg; Gas Connector Length: 30 mm; Left Clearance Safe: 100 mm; Left Distance: 638 mm; Liquid Connector Angle: 180 deg; Liquid Connector Length: 5 mm; Right Clearance Safe: 100 mm; Right Distance: 444 mm; Type: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVS-07-24_INT-EN: AVS-07URCSABA; Type Id: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Hisense_AVS-07-24_INT-EN: AVS-07URCSABA
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 150 mm; Front Clearance: 1000 mm; Left Clearance: 100 mm; Left Connection: no; Rear Connection: yes; Right Clearance: 100 mm; Right Connection: no; Service Space: no
